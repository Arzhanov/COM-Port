# Keil uVision project example.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\MDR1986BE4_StdPeriph_Driver;.\MDR1986BE4_StdPeriph_Driver\inc;.\MDR1986BE4_StdPeriph_Driver\src;..\Мелисса-МК
  memory RVCT4: ROM 0x1000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: main.c ADC_test.c ADC_test.h PORT_config.c PORT_config.h CLK_config.c CLK_config.h UART_config.c UART_config.h DAC_config.c DAC_config.h TIMER_config.c TIMER_config.h ReceiveData.c ReceiveData.h SendData.c SendData.h
software components: CMSIS:CORE 5.4.0, Board Support:Board Setup 0.4, Device:Startup 0.4, Drivers:ADC 0.4, Drivers:CLKCTRL 0.4, Drivers:DAC 0.4, Drivers:PORT 0.4, Drivers:TIM 0.4, Drivers:UART 0.4
